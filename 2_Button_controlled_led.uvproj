# Keil uVision project 2_Button_controlled_led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C1051 Microchip
  cpu: IRAM(0 - 0x3F) IROM(0 - 0x3FF) CLOCK(24000000)
  output: 2_Button_controlled_led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led_button.c
